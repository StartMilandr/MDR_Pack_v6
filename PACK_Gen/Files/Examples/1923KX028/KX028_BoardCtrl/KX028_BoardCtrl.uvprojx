# Keil uVision project KX028_BoardCtrl.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE92 Milandr
  pack: Milandr.MDR1986VExx.2.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KX028_BoardCtrl
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_BASIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./src/: main.c KX028_CLI.c KX028_Ctrl.c
software components: Board Support:BoardDefs 2.0, Device:Startup 2.0, Drivers:Backup and RTC 2.0, Drivers:DMA 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:Timer 2.0, Drivers:UART 2.0, Drivers:UART_CLI 2.0, Drivers:UseFuncs 2.0, IC Drivers:SN74HC595D 2.0, MDR_1923KX028:1923KX028_Core 2.0, MDR_1923KX028:1923KX028_Mode2 2.0
