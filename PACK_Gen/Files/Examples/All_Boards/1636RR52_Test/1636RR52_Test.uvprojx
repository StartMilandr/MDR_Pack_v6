# Keil uVision project 1636RR52_Test.uvprojx, settings and files
target 1986VK214 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VK214 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 1636RR52_Test
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\1636RR52_Test
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ./: main.c
target 1986VK234 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VK234 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: as above
  output: 1636RR52_Test
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\1636RR52_Test
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: Board Support:Buttons 2.0, Board Support:SSP_PinSelect 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0, IC Drivers:1636RR52 2.0
