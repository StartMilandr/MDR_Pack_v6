# Keil uVision project ADC_Test_VK214.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VK214 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ADC_Test_VK214
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\ADC_Test
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: main.c ADC_cfg.c test_ADC_CyclicOne.c test_ADC_CyclicSel.c test_ADC_ManualOne.c test_ADC_ManualSel.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Device:Startup 2.0, Drivers:ADC 2.0, Drivers:GPIO Port 2.0, Drivers:LCD 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:SysTimer 2.0, Drivers:UseFuncs 2.0
