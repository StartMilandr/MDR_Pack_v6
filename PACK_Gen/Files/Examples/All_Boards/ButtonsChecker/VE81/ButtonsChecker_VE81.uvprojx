# Keil uVision project ButtonsChecker_VE81.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE81 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x8000) IROM(0x01000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ButtonsChecker_VE81
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\ButtonsChecker
  memory RVCT4: ROM 0x1000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../: main.c
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:UseFuncs 2.0
