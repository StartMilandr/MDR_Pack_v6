# Keil uVision project CAN_Test.uvprojx, settings and files
target VE8 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20002000,0x6000) IROM(0x20000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN_Test
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group user
    ./: main.c
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Device:Startup 2.0, Drivers:CAN 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:UseFuncs 2.0
