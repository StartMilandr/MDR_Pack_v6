# Keil uVision project DMA_SPI.uvprojx, settings and files
target 1986VK234 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986VK234 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DMA_SPI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\DMA_SPI
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ./: main.c MDRB_SPI_SelectPins.c
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Device:Startup 2.0, Drivers:DMA 1.9, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:UseFuncs 2.0
