# Keil uVision project DMA_UART_RX.uvprojx, settings and files
target VE8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DMA_UART_RX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group user
    ./: main.c
target VE92 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE92 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA_UART_RX
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: Board Support:UART_Debug 2.0, Device:Startup 2.0, Device:Startup 2.0, Drivers:DMA 2.0, Drivers:GPIO Port 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:RST Clock 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
