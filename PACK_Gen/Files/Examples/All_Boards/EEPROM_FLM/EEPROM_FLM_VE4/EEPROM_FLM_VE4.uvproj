# Keil uVision project EEPROM_FLM_VE4.uvproj, settings and files
target Cortex-M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MDR1986VE4_EEPROM
  AfterMake: cmd.exe /C copy "Objects\%L" "..\@L.FLM"
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_MDR1986VE4 FIX_DBL_READ
  c misc: --no_debug_macros -Ospace
  c include: ..\..\EEPROM_FLM\src;..\src\Devices\Defines;..\src\Devices\MDR1986VE9x
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../src/: FlashPrg_VE4.c MDR_EEPROM_VE4_min.c
  group Device Description
    ./: FlashDev.c
  group Stack Size
    ./: FlashStk.s
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
