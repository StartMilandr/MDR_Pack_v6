# Keil uVision project EEPROM_FLM_VE9x.uvproj, settings and files
target Cortex-M (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MDR1986VE9x_EEPROM
  AfterMake: cmd.exe /C copy "Objects\%L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: USE_MDR1986VE9x
  c misc: --no_debug_macros -Ospace
  c include: ..\..\EEPROM_FLM\src;..\src\Devices\Defines;..\src\Devices\MDR1986VE9x
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../src/: FlashPrg.c MDR_EEPROM_min.c
  group Device Description
    ./: FlashDev.c
  group Stack Size
    ./: FlashStk.s
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
