# Keil uVision project OTPSRAM_FLM_VE81.uvproj, settings and files
target Cortex-M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: MDR1986VE81_OTPSRAM
  AfterMake: cmd.exe /C copy "Objects\%L" "..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_MDR1986VE4
  c misc: --no_debug_macros -Ospace
  c include: ..\src
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../src/: FlashPrg_VE8.c
  group Device Description
    ./: FlashDev.c
  group Stack Size
    ./: FlashStk.s
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
