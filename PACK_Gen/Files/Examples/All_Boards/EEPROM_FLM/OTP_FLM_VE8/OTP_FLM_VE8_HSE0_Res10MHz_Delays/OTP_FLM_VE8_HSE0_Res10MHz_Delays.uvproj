# Keil uVision project OTP_FLM_VE8_HSE0_Res10MHz_Delays.uvproj, settings and files
target Cortex-M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: _MDRVE8_OTP_HSE0_10MD
  AfterMake: cmd.exe /C copy "Objects\%L" "..\..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_MDR1986VE8 USE_HSE0_RES_10MHZ MDR_VE8_ERRATA_0051_Fixed
  c misc: --no_debug_macros -Ospace
  c include: ..\..\src;..\..\src\VE8
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../../src/VE8/: MDR_BKP_RTC_VE8x.c MDR_Funcs.c MDR_OTP_VE8x.c MDR_RST_Clock_VE8x.c MDR_GPIO_VE8x.c
    ../../src/: FlashPrg_VE8_Delays.c
  group Device Description
    ./: FlashDev.c
  group Stack Size
    ./: FlashStk.s
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
