<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\FLM_Test_VE1\FLM_Test_VE1.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>.\FLM_Test_VE9x\FLM_Test_VE9x.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\FLM_Test_VE4\FLM_Test_VE4.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\FLM_Test_VE81\FLM_Test_VE81.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\FLM_Test_VE8\FLM_Test_VE8.uvprojx</PathAndName>
  </project>

</ProjectWorkspace>
