# Keil uVision project FLM_Test_VE4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: FLM_Test_VE4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_MDR1986VE4
  c include: ..\..\src
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group user
    ../: main.c
    ../../src/: MDR_EEPROM_VE4_min.c FlashPrg_VE4.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
