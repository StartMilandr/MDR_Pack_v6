# Keil uVision project FLM_Test_VE8.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: FLM_Test_VE8
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_MDR1986VE8 USE_HSE0_RES_10MHZ MDR_VE8_ERRATA_0051_Fixed
  c include: ..\..\src;..\..\src\VE8;..\..\test
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group user
    ../../src/VE8/: MDR_BKP_RTC_VE8x.c MDR_Funcs.c MDR_OTP_VE8x.c MDR_RST_Clock_VE8x.c MDR_GPIO_VE8x.c
    ../: main_VE8.c
    ../../src/: FlashPrg_VE8_Delays.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
