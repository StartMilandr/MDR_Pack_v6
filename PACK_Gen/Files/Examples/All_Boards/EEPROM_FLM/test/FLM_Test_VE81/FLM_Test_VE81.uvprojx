# Keil uVision project FLM_Test_VE81.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: FLM_Test_VE81
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_MDR1986VE81
  c include: ..\..\src;..\FLM_Test_VE81
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x4000
  group user
    ../: main_VE81.c
    ../../src/: FlashPrg_VE8.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
