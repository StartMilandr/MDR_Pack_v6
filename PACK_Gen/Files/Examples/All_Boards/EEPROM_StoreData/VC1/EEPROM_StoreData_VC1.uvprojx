# Keil uVision project EEPROM_StoreData_VC1.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1901VC1 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EEPROM_StoreData_VC1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_MDR1901VC1
  c include: ..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c test_EEPROM_BuffWRRD.c test_EEPROM_PageWRRD.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Device:Startup 2.0, Drivers:Backup and RTC 2.0, Drivers:EEPROM 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:SysTimer 2.0, Drivers:UseFuncs 2.0
