# Keil uVision project EEPROM_Test_VK214.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986VK214 Milandr
  pack: Milandr.MDR1986VExx.2.01
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EEPROM_Test_VK214
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\src
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x1000
  group user
    ../src/: EEPROM_PageFuncs_CM0.c main_214.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Device:Startup 2.0, Drivers:EEPROM 2.0, Drivers:GPIO Port 2.0, Drivers:LCD 2.0, Drivers:RST Clock 2.0, Drivers:UseFuncs 2.0
