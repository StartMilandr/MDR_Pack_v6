# Keil uVision project ETH_HSR_Echo_RedBox.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR_MLDR155 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ETH_HSR_Echo_RedBox
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./: main.c
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Device:Startup 2.0, Drivers:DMA 2.0, Drivers:Ethernet 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:Timer 2.0, Drivers:UseFuncs 2.0, HSR_PRP:HSR 1.0.0
