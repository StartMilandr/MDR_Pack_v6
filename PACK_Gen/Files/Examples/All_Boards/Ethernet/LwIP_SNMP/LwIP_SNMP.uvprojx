# Keil uVision project LwIP_SNMP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE1 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: Ethernet_UTP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Ethernet_UTP;.\src\MDR_LwIP;.\src\MDR_LwIP\lwip\include;.\src\MDR_LwIP\lwip_mdr_port;.\src\MDR_LwIP\lwip_mdr_port\netif;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  scatter file: ..\Ethernet_MAC_Echo\MDR1986VE1T_sctr.txt
  group user
    ./: main.c
    ./src/MDR_LwIP/lwip_mdr_port/: MDR_ethernetif.c
    ./src/MDR_LwIP/: MDR_LwIP.c MDR_LwIP_Timer.c
    ./src/: UserMIB.c
  group LwIP
    ./src/MDR_LwIP/lwip/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./src/MDR_LwIP/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./src/MDR_LwIP/lwip/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./src/MDR_LwIP/lwip/netif/: ethernet.c
  group SNMP
    ./src/MDR_LwIP/lwip/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Device:Startup 2.0, Drivers:DMA 2.0, Drivers:Ethernet 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:Timer 2.0, Drivers:UseFuncs 2.0
