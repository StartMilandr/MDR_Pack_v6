# Keil uVision project FreeRTOS_Leds.uvprojx, settings and files
target VE3 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE3 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Leds
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group user
    ./: main.c
target VE92 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE92 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Leds
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target VE8 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20002000,0x6000) IROM(0x20000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_Leds
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x6000
target VE4 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE4 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Leds
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target VC1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1901VC1 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: as above
  output: FreeRTOS_Leds
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: Board Support:LED 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:RST Clock 2.0, Drivers:Timer 2.0, Drivers:UseFuncs 2.0, FreeRTOS:Core 10.3.1
