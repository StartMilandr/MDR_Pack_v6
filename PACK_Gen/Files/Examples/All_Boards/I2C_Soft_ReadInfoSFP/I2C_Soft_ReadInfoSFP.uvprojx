# Keil uVision project I2C_Soft_ReadInfoSFP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE1 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: I2C_Soft_ReadInfoSFP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group user
    ./: main.c
software components: Board Support:Buttons 2.0, Board Support:UART_Debug 2.0, Board Support:UART_PinSelect 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:Soft Master I2C 2.0, Drivers:Timer 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0, IC Drivers:SFP modules 2.0
