# Keil uVision project LED_Flasher_ESila.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR_ESila Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Flasher_ESila
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../: main.c
software components: Board Support:LED 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:SysTimer 2.0, Drivers:UseFuncs 2.0
