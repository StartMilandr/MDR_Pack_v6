# Keil uVision project LED_Flasher_VE8.uvprojx, settings and files
target Target 1 (6060000::V6.6::.\ARMCLANG)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Flasher_VE8
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_MDR1986VE8
  c include: ..\..\LedFlasher
  memory RVCT4: ROM 0x20006000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group user
    ../: main.c
software components: Board Support:LED 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:SysTimer 2.0, Drivers:UseFuncs 2.0
