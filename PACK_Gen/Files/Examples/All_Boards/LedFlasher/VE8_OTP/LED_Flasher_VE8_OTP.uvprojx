# Keil uVision project LED_Flasher_VE8_OTP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20002000,0x6000) IROM(0x20000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Flasher_VE8_OTP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\LedFlasher
  memory RVCT4: ROM 0x101d000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../: main.c
software components: Board Support:LED 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:SysTimer 2.0, Drivers:UseFuncs 2.0
