# Keil uVision project OTPSRAM_Test_VE81.uvprojx, settings and files
target VE81 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE81 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x8000) IROM(0x01000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OTPSRAM_Test_VE81
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group user
    ./: main.c
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:OTP_VE8x 2.0, Drivers:RST Clock 2.0, Drivers:UseFuncs 2.0
