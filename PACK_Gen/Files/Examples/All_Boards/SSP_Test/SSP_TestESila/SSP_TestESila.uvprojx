# Keil uVision project SSP_TestESila.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR_ESila Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SSP_TestESila
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\SSP_TestESila
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../src/: main.c SSP_cfg.c SSP_CommonFuncs.c test_Microwire.c test_SPI_DataBits.c test_SPI_Frames.c test_SPI_IRQ.c test_SPI_LBM.c test_SPI_LBM_ALL.c test_SPI_MasterSlave.c test_SPI_TXRT.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:UseFuncs 2.0
