# Keil uVision project SSP_TestVE8.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SSP_TestVE8
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\SSP_TestVE8
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20005000 size 0x3000
  group user
    ../src/: main.c SSP_cfg.c SSP_CommonFuncs.c test_SPI_LBM.c test_SPI_TXRT.c
software components: Board Support:Buttons 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
