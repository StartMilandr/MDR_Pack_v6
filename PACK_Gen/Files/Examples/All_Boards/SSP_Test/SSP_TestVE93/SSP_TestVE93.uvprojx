# Keil uVision project SSP_TestVE93.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE93 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SSP_TestVE93
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c SSP_cfg.c test_SPI_LBM.c test_SPI_LBM_ALL.c test_SPI_TXRT.c SSP_CommonFuncs.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:UseFuncs 2.0
