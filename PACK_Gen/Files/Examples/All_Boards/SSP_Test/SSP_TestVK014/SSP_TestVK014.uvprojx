# Keil uVision project SSP_TestVK014.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1923VK014 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SSP_TestVK014 +hex
  AfterMake: cmd.exe /C copy "Objects\SSP_TestVK014.hex" "SSP_TestVK014.hex"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\src;..\SSP_TestVK014
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c SSP_cfg.c SSP_CommonFuncs.c test_Microwire.c test_SPI_DataBits.c test_SPI_Frames.c test_SPI_IRQ.c test_SPI_LBM.c test_SPI_LBM_ALL.c test_SPI_MasterSlave.c test_SPI_TXRT.c
software components: Board Support:Buttons 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
