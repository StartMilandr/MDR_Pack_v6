# Keil uVision project Timer_CapFix.uvprojx, settings and files
target 1986VE4 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE4 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Timer_CapFix
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ./: main.c
target 1986VE1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE1 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: Timer_CapFix
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
target 1986VE3 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE3 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: as above
  output: Timer_CapFix
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
target 1986VE91 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE91 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Timer_CapFix
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 1901VC1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1901VC1 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: as above
  output: Timer_CapFix
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_MDR1901VC1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 1986VK234 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VK234 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Timer_CapFix
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Board Support:Timer_PinSelect 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:Timer 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
