# Keil uVision project Timer_Test_VE8.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Timer_Test_VE8
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group user
    ../src/: main.c MDRB_ShowMess.c test_CAP_Period.c test_CAP_Simplest.c test_CascadeTimer.c test_CountTimClock.c test_Pulse.c test_PWM.c test_PWM_ClearBRKETR.c test_PWM_CountCAP.c test_PWM_CountETR.c test_PWM_DTG.c test_SimplestFlash.c
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Board Support:Timer_PinSelect 2.0, Board Support:UART_Debug 2.0, Board Support:UART_PinSelect 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:Timer 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
