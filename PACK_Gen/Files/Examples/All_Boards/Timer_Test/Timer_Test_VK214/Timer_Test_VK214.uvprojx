# Keil uVision project Timer_Test_VK214.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986VK214 Milandr
  pack: Milandr.MDR1986VExx.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Timer_Test_VK214
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\src;..\Timer_Test_VK214
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: main.c test_SimplestFlash.c test_CountTimClock.c test_CascadeTimer.c test_Pulse.c test_PWM.c test_PWM_DTG.c test_PWM_ClearBRKETR.c test_CAP_Simplest.c test_CAP_Period.c test_PWM_CountETR.c test_PWM_CountCAP.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Board Support:LED 2.0, Board Support:Timer_PinSelect 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:LCD 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:Timer 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
