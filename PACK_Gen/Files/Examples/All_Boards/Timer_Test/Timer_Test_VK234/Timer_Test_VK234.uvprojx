# Keil uVision project Timer_Test_VK234.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VK234 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Timer_Test_VK234
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\src;..\Timer_Test_VK234
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: main.c test_CascadeTimer.c test_CountTimClock.c test_SimplestFlash.c test_Pulse.c test_PWM.c test_PWM_DTG.c test_PWM_ClearBRKETR.c test_CAP_Simplest.c test_CAP_Period.c test_PWM_CountETR.c test_PWM_CountCAP.c MDRB_ShowMess.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Board Support:LED 2.0, Board Support:Timer_PinSelect 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:Timer 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
