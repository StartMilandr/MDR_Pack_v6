# Keil uVision project UART_CLI_Test.uvprojx, settings and files
target VC1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1901VC1 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART_CLI_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./: main.c
target VE3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE3 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: UART_CLI_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  scatter file: .\MDR1986VE3T_sct.txt
target VE1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE1 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: as above
  output: UART_CLI_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  scatter file: .\MDR1986VE3T_sct.txt
software components: Board Support:Buttons 2.0, Board Support:LED 2.0, Board Support:UART_PinSelect 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Drivers:DMA 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:UART 2.0, Drivers:UART_CLI 2.0, Drivers:UseFuncs 2.0
