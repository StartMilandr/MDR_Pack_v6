# Keil uVision project UART_TestVC1.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MDR1901VC1 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART_TestVC1
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_MDR1901VC1
  c include: ..\src;..\UART_TestVC1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c test_Debug.c
software components: Board Support:Buttons 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
