# Keil uVision project ADCUI_VE4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE4 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ADCUI_VE4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ./: main.c
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Drivers:ADCUI 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:SysTimer 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
