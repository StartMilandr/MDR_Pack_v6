# Keil uVision project ADC_Temperature.uvprojx, settings and files
target 1986VE3T (6060000::V6.6::.\ARMCLANG)
  device: MDR1986VE3 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: ADC_Temperature
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group user
    ./: main.c
target 1986VE91T (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986VE91 Milandr
  pack: Milandr.MDR1986VExx.2.0x
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC_Temperature
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: Board Support:Buttons 2.0, Board Support:DisplayLCD 2.0, Board Support:UART_Debug 2.0, Device:Startup 2.0, Device:Startup 2.0, Drivers:ADC 2.0, Drivers:GPIO Port 2.0, Drivers:PER_Clock 2.0, Drivers:RST Clock 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0
