# Keil uVision project DelayAsm_Test.uvprojx, settings and files
target VE4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE4 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DelayAsm_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ./: main.c DelayTst.c
target VE93 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE93 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DelayAsm_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target VE1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE1 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: DelayAsm_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20100000 size 0x4000
target VE8 (6120000::V6.12::.\ARMCLANG)
  device: MDR1986VE8 Milandr
  pack: Milandr.MDR1986VExx.2.04
  cpu: IRAM(0x20002000,0x6000) IROM(0x20000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DelayAsm_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x6000
software components: Board Support:LED 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Device:Startup 2.0, Drivers:GPIO Port 2.0, Drivers:GPIO Port 2.0, Drivers:RST Clock 2.0, Drivers:RST Clock 2.0, Drivers:UseFuncs 2.0
