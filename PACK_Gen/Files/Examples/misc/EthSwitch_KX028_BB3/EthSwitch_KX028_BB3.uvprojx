# Keil uVision project EthSwitch_KX028_BB3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VE1 Milandr
  pack: Milandr.MDR1986VExx.2.05
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: EthSwitch_KX028_BB3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group user
    ./src/: main.c KX028_Ctrl.c BB3_Ctrl.c ePHY_Ctrl.c Reset_Ctrl.c MDR_1923KX028_TableMAC.c MDR_1923KX028_ErrLog.c MDR_1923KX028_TableVLAN.c MDR_1923KX028_M2_Stats.c MDR_1923KX028_M2_TablesCtrl.c MDR_1923KX028_M2_Defs.c MDR_1923KX028_M2_Ctrl.c MDR_1923KX028_M2_Init.c
software components: Device:Startup 2.0, Drivers:DMA 2.0, Drivers:Ethernet 2.0, Drivers:GPIO Port 2.0, Drivers:JTAG 2.0, Drivers:RST Clock 2.0, Drivers:SSP 2.0, Drivers:UART 2.0, Drivers:UseFuncs 2.0, IC Drivers:1923KX028 2.0, IC Drivers:5600BB3 2.0
